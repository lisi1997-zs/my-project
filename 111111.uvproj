# Keil uVision project 111111.uvproj, settings and files
target Target_1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: 22222 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 common.h ds1302.c ds1302.h lcd1602.c lcd1602.h main.c
